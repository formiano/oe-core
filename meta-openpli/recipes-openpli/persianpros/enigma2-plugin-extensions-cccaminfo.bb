MODULE = "cccaminfo"
DESCRIPTION = "CCcam Info For Persian Palace"
LICENSE = "GPLv2"

PR="r2"

require persianprosplugins-replace-pli.inc

require persianprosplugins-distutils.inc
