MODULE = "devicelabeler"
DESCRIPTION = "Device Labeler For Persian Empire"
LICENSE = "GPLv2"

PR="r2"

require persianprosplugins-replace-pli.inc

require persianprosplugins-distutils.inc
