MODULE = "bouquetsprotection"
DESCRIPTION = "Bouquets Protection For Persian Empire "
LICENSE = "GPLv2"

PR="r2"

require persianprosplugins-replace-pli.inc

require persianprosplugins-distutils.inc
