MODULE = "simplesatscan"
DESCRIPTION = "Simple Sat Scan For Persian Empire"
LICENSE = "GPLv2"

require persianprosplugins-replace-pli.inc

require persianprosplugins-distutils.inc
