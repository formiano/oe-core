MODULE = "fontmagnifier"
DESCRIPTION = "Font Magnifier For Persian Palace"
LICENSE = "GPLv2"

require persianprosplugins-replace-pli.inc

require persianprosplugins-distutils.inc
